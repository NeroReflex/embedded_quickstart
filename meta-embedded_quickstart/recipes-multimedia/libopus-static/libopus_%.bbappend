
PACKAGECONFIG = "
    --enable-static \
    --enable-shared \
"
